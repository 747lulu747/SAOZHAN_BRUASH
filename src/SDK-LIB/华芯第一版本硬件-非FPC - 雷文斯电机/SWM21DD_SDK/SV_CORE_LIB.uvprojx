# Keil uVision project SV_CORE_LIB.uvprojx, settings and files
target LIB (5030076::V5.03 [Build 76]::ARMCC)
  device: SWM211x8 Synwit
  pack: Synwit.SWM32_DFP.1.20.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SV_CORE_LIB (library)
  AfterMake: cmd.exe /C copy /y "D:\项目\罗曼扫动牙刷\src\ROMAN-21DD - SDK - V0.1\core_lib\SV_CORE_LIB.lib" "D:\项目\罗曼扫动牙刷\src\ROMAN-21DD - SDK - V0.1 - release\core_lib\"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CSL\CMSIS\CoreSupport;.\APP\include;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM2X1_StdPeriph_Driver;.\APP\source\Hardware;..\inc_lib
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ./APP/source/FOC/: Foc.c foc_util.c PiController.c Pll.c

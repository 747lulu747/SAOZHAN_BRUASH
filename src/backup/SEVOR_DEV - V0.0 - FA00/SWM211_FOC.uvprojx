# Keil uVision project SWM211_FOC.uvprojx, settings and files
target SWM211 (5030076::V5.03 [Build 76]::ARMCC)
  device: SWM211x8 Synwit
  pack: Synwit.SWM32_DFP.1.20.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: SWM21P
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: CHIP_SWM211
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM2X1_StdPeriph_Driver;.\User;.\APP\include;.\APP\source\Hardware
  asm define: CHIP_SWM211
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\out\SWM21P.sct
  group Application
    ./APP/source/Application/: main.c Interrupt.c Flash.c retarget.c util.c test.c IRScan.c IRControl.c fan.c software_pwm.c rgb.c main_light.c mills_app.c
    ./APP/include/: Protect.h Parameter.h Customer.h MyProject.h
  group FOC
    ./APP/source/FOC/: SWM21P20230328.lib Foc.c PiController.c Pll.c foc_util.c foc_interface.c
  group Hardware
    ./APP/source/Hardware/: GPIO.c ADC.c OPA.c PWM_DRIVE.c TIMER.c CMP.c FLASH.c UART.c
  group CSL\StdPD
    ./CSL/SWM2X1_StdPeriph_Driver/: SWM2X1_port.c SWM2X1_gpio.c SWM2X1_exti.c SWM2X1_timr.c SWM2X1_uart.c SWM2X1_adc.c SWM2X1_i2c.c SWM2X1_pwm.c SWM2X1_rtc.c SWM2X1_wdt.c SWM2X1_sleep.c SWM2X1_div.c SWM2X1_cordic.c SWM2X1_spi.c SWM2X1_qei.c SWM2X1_dma.c SWM2X1_can.c SWM201_flash.c SWM211_flash.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM211.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM211.s
  group Document
    ./APP/source/Document/: Debuglog.txt
